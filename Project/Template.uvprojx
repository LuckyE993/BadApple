# Keil uVision project Template.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\Compiler_5.06u7)
  device: GD32F450ZG GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.0.3
  cpu: IRAM(0x20000000,0x030000) IRAM2(0x10000000,0x010000) IROM(0x08000000,0x0100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F450
  c include: ..\User;..\Firmware\CMSIS;..\Firmware\CMSIS\GD\GD32F4xx\Include;..\Firmware\GD32F4xx_standard_peripheral\Include;..\User\bsp_systick;..\Hardware\LED;..\User\bsp_usart;..\User\bsp_dma;..\Hardware\OLED;..\Hardware\SDIO;..\Hardware\FATFS\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Firmware
    ../Firmware/GD32F4xx_standard_peripheral/Source/: gd32f4xx_adc.c gd32f4xx_can.c gd32f4xx_crc.c gd32f4xx_ctc.c gd32f4xx_dac.c gd32f4xx_dbg.c gd32f4xx_dci.c gd32f4xx_dma.c gd32f4xx_enet.c gd32f4xx_exmc.c gd32f4xx_exti.c gd32f4xx_fmc.c gd32f4xx_fwdgt.c gd32f4xx_gpio.c gd32f4xx_i2c.c gd32f4xx_ipa.c gd32f4xx_iref.c gd32f4xx_misc.c gd32f4xx_pmu.c gd32f4xx_rcu.c gd32f4xx_rtc.c gd32f4xx_sdio.c gd32f4xx_spi.c gd32f4xx_syscfg.c gd32f4xx_timer.c gd32f4xx_tli.c gd32f4xx_trng.c gd32f4xx_usart.c gd32f4xx_wwdgt.c
  group CMSIS
    ../Firmware/CMSIS/GD/GD32F4xx/Source/ARM/: startup_gd32f450_470.s
    ../Firmware/CMSIS/GD/GD32F4xx/Source/: system_gd32f4xx.c
  group Doc
    ../Doc/: readme.txt
  group Hardware
    ../Hardware/LED/: bsp_led.c
    ../Hardware/OLED/: oled.c
    ../Hardware/SDIO/: sdcard.c
  group User
    ../User/: gd32f4xx_it.c main.c
    ../User/bsp_systick/: bsp_systick.c
    ../User/bsp_usart/: bsp_usart.c
    ../User/bsp_dma/: bsp_dma.c
  group FATFS
    ../Hardware/FATFS/src/: diskio.c ff.c fattime.c ff_gen_drv.c ffsystem.c ffunicode.c
software components: CMSIS:CORE 5.6.0
